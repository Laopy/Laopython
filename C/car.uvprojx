# Keil uVision project car.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: car +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\APP;.\CMSIS\DeviceSupport\ST\STM32F10x;.\CMSIS\CoreSupport;.\STM32F10x_StdPeriph_Driver\inc;.\Hardware\OLED;.\Hardware\BEEP;.\Hardware\FIRE;.\System\Delay_ms;.\Hardware\Solid;.\Hardware\USART;.\Hardware\bmp;.\Hardware\MLX90614;.\Hardware\Mator
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: .\Objects\car.sct
  group APP
    ./APP/: main.c stm32f10x_it.c
  group CMSIS
    ./CMSIS/CoreSupport/: core_cm3.c
    ./CMSIS/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Driver
    ./STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Hardware
    ./Hardware/OLED/: OLED.c
    ./Hardware/FIRE/: fire.c
    ./Hardware/BEEP/: beep.c
    ./Hardware/Solid/: Solid.c
    ./Hardware/Mator/: Mator.c
  group System
    ./System/Delay_ms/: Delay_ms.c
  group usart
    ./Hardware/USART/: USART.c
  group BMP
    ./Hardware/bmp/: bmp.c
  group MLX90614
    ./Hardware/MLX90614/: MLX90614.c
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev, Device:GPIO 1.3, Device:Startup 1.0.0
